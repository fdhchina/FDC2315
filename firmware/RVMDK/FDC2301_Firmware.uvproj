# Keil uVision project FDC2301_Firmware.uvproj, settings and files
target FDC2301_Firmware (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FDC2301_Firmware +hex
  AfterMake: fromelf.exe --bin -o "$L..\FDC215.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD
  c include: ..\..\Lib\STM32Lib;..\src\U_HOST;..\src;..\src\Drivers\Filesystem;..\src\Drivers;..\src\usr;..\..\Lib\USBLib\inc;..\src\Drivers\Filesystem\MSD;..\src\Drivers\Mass_Storage;..\src\audioinfo
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Usr
    ../src/: main.c stm32f10x_it.c log.c
    ../src/usr/: player.c Task.c arrayList.c stringconst.c menu.c queue.c remoteTask.c
    ../src/Drivers/: tuner.c
  group FwLib
    ../../Lib/STM32Lib/: system_stm32f10x.c core_cm3.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_iwdg.c
  group StartUp
    ../../Lib/STM32Lib/StartUp/: startup_stm32f10x_hd.s
  group Driver
    ../src/Drivers/: 25f.c AmpMeter.c GPIO.c hal.c key.c lcm19264.c RCC.c usrkey.c VS1003x.c DS3231.c audio.c i2c_ee.c stmflash.c Com.c zk.c
    ../src/Drivers/Filesystem/: cc936.c diskio.c ff.c ch375.c
    ../src/Drivers/Filesystem/MSD/: msd.c
    ../src/Drivers/si47xx/: SI47XX.C
    ../src/Drivers/Filesystem/U_HOST/: CH375HFM.LIB
  group audioinfo
    ../src/audioinfo/: ID3v1.c ID3v2.c MPEGaudio.c WAVfile.c WMAfile.c
  group Readme
    ../../readme/: Readme.txt
