# Keil uVision project FDC2301_Boot.uvproj, settings and files
target SM1301_Bootload (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SM1301_bootload
  AfterMake: fromelf.exe --bin -o "$L..\SM1301_boot.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Lib\STM32Lib;..\src\U_HOST;..\src
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Usr
    ../src/: hal.c main.c RCC.c ch375.c stmflash.c lcm19264.c usrkey.c key.c
    ../src/U_HOST/: CH375HFM.LIB
  group FwLib
    ../../Lib/STM32Lib/: system_stm32f10x.c core_cm3.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
  group StartUp
    ../../Lib/STM32Lib/StartUp/: startup_stm32f10x_hd.s
